options:
  parameters:
    generate_options: qt_gui
    id: first_contact_with_gnuradio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: 10e3
    value: 1e3
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Noise (V)
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,3,1
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,3,1
    size: '512'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
